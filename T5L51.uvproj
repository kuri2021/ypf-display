# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: 1.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\source;.\lib
  group startup
    ./: STARTUP_M5.A51
  group driver
    ./driver/: sys.c timer.c uart.c debug.c
  group application
    ./source/: main.c include.h ui.c history.c admin.c color.c language.c dwin8283.c
  group lib
    ./lib/: dwin8283.c canbus.c norflash.c rtc.c umath.c encoder.c
    ./driver/: iic.c
